# Repository Yowie-Tool/Scanner-Dev (continued)

## KiCad design Universal Interface Board/Universal Interface Board - Copy.kicad_pcb (continued)

Board: 2 copper layers, 65.0 x 59.7 mm, 52 parts (1 on the bottom side), 26 nets.

Other parts of the board:
Fan1, Fan2, Fan3, Fan4: MountingHole_3.2mm_M3_ISO14580

File Universal Interface Board/Universal Interface Board - Copy_bom_1.csv:

Component,Description,Part,References,Value,Footprint,Quantity Per PCB,Datasheet,Field4,Field5,Field6,Field7,Field8,Category,DK_Datasheet_Link,DK_Detail_Page,Digi-Key_PN,Family,MPN,Manufacturer,Status
1,Single-cell battery,Battery_Cell,BT1,Battery_Cell,BatteryHolder_Keystone_3001_1x12mm,1,~,,,,,,,,,,,,,
2,Unpolarized capacitor,C,Cin9 Cout2,0.1uF,C_0805_2012Metric_Pad1.15x1.40mm_HandSolder,2,~,,,,,,,,,,,,,
3,Unpolarized capacitor,C,Cin7 Cin8,100nF,C_0603_1608Metric_Pad1.05x0.95mm_HandSolder,2,~,,,,,,,,,,,,,
4,Polarized capacitor,CP,Cin1,100uF,CP_Radial_D6.3mm_P2.50mm,1,~,,,,,,,,,,,,,
5,Unpolarized capacitor,C,Cin5,10nF,C_0603_1608Metric_Pad1.05x0.95mm_HandSolder,1,~,,,,,,,,,,,,,
6,Unpolarized capacitor,C,Cin2 Cin3 Cin6,10uF,C_1206_3216Metric_Pad1.42x1.75mm_HandSolder,3,~,,,,,,,,,,,,,
7,Polarized capacitor,CP,Cin4,680uF,CP_Radial_D10.0mm_P5.00mm,1,~,,,,,,,,,,,,,
8,Unpolarized capacitor,C,Cout4,2.2nF,C_0603_1608Metric_Pad1.05x0.95mm_HandSolder,1,~,,,,,,,,,,,,,
9,Unpolarized capacitor,C,Cout1 Cout3,22uF,C_1210_3225Metric_Pad1.42x2.65mm_HandSolder,2,~,,,,,,,,,,,,,
10,Diode,D,D1,BAS21H,D_SOD-123F,1,~,,,,,,,,,,,,,
11,Fuse,Fuse,F1,Fuse 1A,Fuse_Littelfuse_395Series,1,~,,,,,,,,,,,,,
12,,647676-2,J1 J2,647676-2,TE_647676-2,2,Compliant,3.96 mm[.156 in],https://www.te.com/usa-en/product-647676-2.html?te_bu=Cor&te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,Header,2,647676-2,,,,,,,,
13,"Generic connector, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x02,J5,Conn_01x02,PinHeader_1x02_P2.54mm_Vertical,1,~,,,,,,,,,,,,,
14,"Generic connector, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x02,J6,Conn_01x02,PinHeader_1x02_P2.54mm_Horizontal,1,~,,,,,,,,,,,,,
15,"Generic screw terminal, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/)",Screw_Terminal_01x02,J3,Screw_Terminal_01x02,TerminalBlock_bornier-2_P5.08mm,1,~,,,,,,,,,,,,,
16,Capacitor symbol for simulation only,INDUCTOR,L1,22uH,L_Wuerth_HCI-7050,1,https://docs.rs-online.com/ec8a/0900766b810c024f.pdf,,,,,,,,,,,,,
17,Fan,Fan,M1,Fan,SolderWirePad_1x02_P3.81mm_Drill1mm,1,~,,,,,,,,,,,,,
18,"Generic connector, double row, 02x20, odd/even pin numbering scheme (row 1 odd numbers, row 2 even numbers), script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_02x20_Odd_Even,P1,Conn_02x20_Odd_Even,PinSocket_2x20_P2.54mm_Vertical,1,,,,,,,,,,,,,,
19,MOSFET N-CH 50V 220MA SOT-23,BSS138,Q1 Q2,BSS138,SOT-23-3,2,https://www.onsemi.com/pub/Collateral/BSS138-D.PDF,,,,,,Discrete Semiconductor Products,https://www.onsemi.com/pub/Collateral/BSS138-D.PDF,/product-detail/en/on-semiconductor/BSS138/BSS138CT-ND/244294,BSS138CT-ND,"Transistors - FETs, MOSFETs - Single",BSS138,ON Semiconductor,Active
20,,DMG2305UX-7,Q3,DMG2305UX-7,SOT91P240X110-3N_DMG2305UX-7,1,Diodes Inc.,1.1mm,IPC-7351B,09/2018,,,,,,,,,,
21,,DMMT5401-7,Q4,DMMT5401-7,SOT26,1,,,,,,,,,,,,,,
22,,IRFML8244TRPBF,Q5,IRFML8244TRPBF,SOT-23,1,INTERNATIONAL RECTIFIER,IRFML8244TRPBF,1857298,25T5496,SOT-23-3,,,,,,,,,
23,Resistor,R,R1,10K,R_0603_1608Metric_Pad1.05x0.95mm_HandSolder,1,~,,,,,,,,,,,,,
24,Resistor,R,R6,10K,R_0805_2012Metric_Pad1.15x1.40mm_HandSolder,1,~,,,,,,,,,,,,,
25,Resistor,R,R4,1K,R_0603_1608Metric_Pad1.05x0.95mm_HandSolder,1,~,,,,,,,,,,,,,
26,Resistor,R,R2 R3 R7 R8,4.7K,R_0603_1608Metric_Pad1.05x0.95mm_HandSolder,4,~,,,,,,,,,,,,,
27,Resistor,R,R5,47K,R_0603_1608Metric_Pad1.05x0.95mm_HandSolder,1,~,,,,,,,,,,,,,
28,"4 resistor network, parallel topology, DIP package",R_Pack04,RN1,10K,R_Array_Convex_4x1206,1,~,,,,,,,,,,,,,
29,"Positive 1A 35V Linear Regulator, Fixed Output 5V, TO-220",LM7805_TO220,U6,193-4043 ,193-4043,1,https://docs.rs-online.com/fc3c/A700000006631878.pdf,,,,,,,,,,,,,
30,"128 kb CMOS Serial EEPROM, SOIC-8/TSSOP-8/DFN-8",CAT24C128,U1,CAT24C128,SOIC-8_3.9x4.9mm_P1.27mm,1,https://www.onsemi.com/pub/Collateral/CAT24C128-D.PDF,,,,,,,,,,,,,
31,IC RTC CLK/CALENDAR I2C 8-DIP,DS1307_,U3,DS1307_,SOIC-8_3.9x4.9mm_P1.27mm,1,https://datasheets.maximintegrated.com/en/ds/DS1307.pdf,,,,,,Integrated Circuits (ICs),https://datasheets.maximintegrated.com/en/ds/DS1307.pdf,/product-detail/en/maxim-integrated/DS1307-/DS1307--ND/956883,DS1307+-ND,Clock/Timing - Real Time Clocks,DS1307+,Maxim Integrated,Active
32,"Low-drop Voltage Regulator, Io up to 500mA, Fixed Vo 5.0V, TO-220",LF50_TO220,U2,LF50_TO220,DPAK,1,http://www.st.com/content/ccc/resource/technical/document/da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,,,,,,,,,,,,,
33,"InvenSense 6-Axis Motion Sensor, Gyroscope, Accelerometer, I2C",MPU-6050,U4,MPU-6050,InvenSense_QFN-24_4x4mm_P0.5mm,1,https://store.invensense.com/datasheets/invensense/MPU-6050_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,,,,,,,,,,,,,
34,"Four pin crystal, GND on pins 2 and 3",Crystal_GND23,Y1,Crystal_GND23,Crystal_SMD_Abracon_ABS25-4Pin_8.0x3.8mm,1,~,,,,,,,,,,,,,

Component Groups:,34
Component Count:,44
Fitted Components:,44
Number of PCBs:,1
Total components:,44
Schematic Version:,1
Schematic Date:,2020-01-13
PCB Variant:,['default']
BoM Date:,08/05/2020 20:29:41
Schematic Source:,Universal Interface Board - Copy.sch
KiCad Version:,Eeschema (5.1.0)-1

## KiCad design Stepper motor controller/Stepper motor controller V2.kicad_pcb

Board: 2 copper layers, 43.0 x 39.9 mm, 33 parts (22 on the bottom side), 29 nets.

Parts:
A1: Pololu_Breakout_A4988; Pololu_Breakout-16_15.2x20.3mm
C1: 1.0uF; C_0805_2012Metric
C2: 2.2uF; C_0805_2012Metric
C3, C4, C5, C6, C8, C20, C21, C22: 0.1uF; C_0805_2012Metric
C7: 100uF; CAPPM7343X310N
C18: 470pF; C_0805_2012Metric
C19: 10uF; C_0805_2012Metric
D1: LED; LED_PLCC-2
J1 - Stepper: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2 - Control: Conn_01x05; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J4 - ICSP: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
JP1: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
MOUNT1, MOUNT2, MOUNT3, MOUNT4: MountingHole_2.7mm_M2.5_ISO7380
R1: 1M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6: 270R; R_0805_2012Metric
R7, R8, R9, R10: 10K; R_0805_2012Metric
U1: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
U2: AP2204R-5.0; SOT-89-3
U4: AS5048B; TSSOP-14_4.4x5mm_P0.65mm
Y1: Crystal_GND2; Resonator_SMD_muRata_CSTxExxV-3Pin_3.0x1.1mm_HandSoldering

Connections:
+5V: A1.2, C2.1, C4.2, C5.2, C6.2, C8.2, C21.2, J4 - ICSP.2, R9.2, U1.4, U1.6, U1.18, U2.3, U4.11
+12V: A1.8, C1.1, C7.1, J2 - Control.1, U2.1
CS: A1.12, U1.10
DIR: A1.16, U1.2
ENABLE: A1.9, R7.1, U1.9
GND: A1.1, A1.7, C1.2, C2.2, C3.2, C4.1, C5.1, C6.1, C7.2, C8.1, C18.2, C19.2, C21.1, C22.2, D1.1, J2 - Control.5, J4 - ICSP.6, R8.1, R10.1, U1.3, U1.5, U1.21, U2.2, U4.5, U4.13, Y1.2
MISO: J4 - ICSP.1, JP1.3, U1.16
MOSI: A1.10, J4 - ICSP.4, U1.15
unnamed: A1.13, JP1.2
unnamed: A1.14, JP1.1
unnamed: C3.1, U1.20
unnamed: C19.1, U4.12
unnamed: D1.2, R7.2
unnamed: R1.1, U1.7, Y1.3
unnamed: R1.2, U1.8, Y1.1
OA1: A1.4, J1 - Stepper.3
OA2: A1.5, J1 - Stepper.2
OB1: A1.3, J1 - Stepper.4
OB2: A1.6, J1 - Stepper.1
PWM: A1.15, U1.1
PWMin: U1.32, U4.14
RESET: C20.2, C22.1, J4 - ICSP.5, R9.1, R10.2, U1.29
RESETin: C20.1, J2 - Control.4, R8.2
RX: J2 - Control.2, U1.30
SCK: A1.11, J4 - ICSP.3, U1.17
SCL: U1.28, U4.2
SDA: U1.27, U4.1
TX: C18.1, R6.1, U1.31
TXin: J2 - Control.3, R6.2

File Stepper motor controller/Stepper motor controller V2_bom_.csv:

Component,Description,Part,References,Value,Footprint,Quantity Per PCB,Datasheet
1,"Pololu Breakout Board, Stepper Driver A4988",Pololu_Breakout_A4988,A1,Pololu_Breakout_A4988,Pololu_Breakout-16_15.2x20.3mm,1,https://www.pololu.com/product/2980/pictures
2,Capacitor symbol for simulation only,CAP,C3 C4 C5 C6 C8 C20 C21 C22,0.1uF,C_0805_2012Metric,8,~
3,Capacitor symbol for simulation only,CAP,C1,1.0uF,C_0805_2012Metric,1,~
4,Capacitor symbol for simulation only,CAP,C7,100uF,CAPPM7343X310N,1,~
5,Capacitor symbol for simulation only,CAP,C19,10uF,C_0805_2012Metric,1,~
6,Capacitor symbol for simulation only,CAP,C2,2.2uF,C_0805_2012Metric,1,~
7,Capacitor symbol for simulation only,CAP,C18,470pF,C_0805_2012Metric,1,~
8,Light emitting diode,LED,D1,LED,LED_PLCC-2,1,~
9,Atmel 6-pin ISP connector,AVR-ISP-6,J4,AVR-ISP-6,PinHeader_2x03_P2.54mm_Vertical,1, ~
10,"Generic connector, single row, 01x04, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x04,J1,Conn_01x04,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,~
11,"Generic connector, single row, 01x05, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x05,J2,Conn_01x05,JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical,1,~
12,"Solder Jumper, 3-pole, open",SolderJumper_3_Open,JP1,SolderJumper_3_Open,SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm,1,~
13,Resistor,R,R7 R8 R9 R10,10K,R_0805_2012Metric,4,~
14,Resistor,R,R1,1M,R_0805_2012Metric_Pad1.15x1.40mm_HandSolder,1,~
15,Resistor,R,R6,270R,R_0805_2012Metric,1,~
16,"150mA low dropout linear regulator, wide input voltage range, 5.0V fixed positive output, SOT-89-3 package",AP2204R-5.0,U2,AP2204R-5.0,SOT-89-3,1,https://www.diodes.com/assets/Datasheets/AP2204.pdf
17,"Magnetic position sensor, 14-bit, PWM output, I2C Interface, TSSOP-14",AS5048B,U4,AS5048B,TSSOP-14_4.4x5mm_P0.65mm,1,https://ams.com/documents/20143/36005/AS5048_DS000298_4-00.pdf
18,"20MHz, 32kB Flash, 2kB SRAM, 1kB EEPROM, TQFP-32",ATmega328P-AU,U1,ATmega328P-AU,TQFP-32_7x7mm_P0.8mm,1,http://ww1.microchip.com/downloads/en/DeviceDoc/ATmega328_P%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
19,"Three pin crystal, GND on pin 2",Crystal_GND2,Y1,Crystal_GND2,Resonator_SMD_muRata_CSTxExxV-3Pin_3.0x1.1mm_HandSoldering,1,~

Component Groups:,19
Component Count:,29
Fitted Components:,29
Number of PCBs:,1
Total components:,29
Schematic Version:,
Schematic Date:,
PCB Variant:,['default']
BoM Date:,10/05/2020 12:34:21
Schematic Source:,Stepper motor controller V2.sch
KiCad Version:,Eeschema (5.1.0)-1

## KiCad design Camera Adapter/Camera Adapter.kicad_pcb

Parts:
C1, C2: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1, J5: 68611514122
J2, J6: 634108150321; WURTH_634108150321
J3: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_01x03; JST_PH_S3B-PH-SM4-TB_1x03-1MP_P2.00mm_Horizontal
R1: 220; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: MC33269D-3.3G; SOIC127P600X175-8N

Connections:
+3V3: C2.1, J1.1 (15), J3.1, J5.1 (15), R1.2, U1.2 (VOUT), U1.3 (VOUT), U1.6 (VOUT), U1.7 (VOUT)
+12V: C1.1, J4.1, U1.4 (VIN)
CAMERA0CN: J1.8, J2.4
CAMERA0CP: J1.7 (9), J2.3
CAMERA0DN0: J1.14 (2), J2.6
CAMERA0DN1: J1.11 (5), J2.8
CAMERA0DP0: J1.13 (3), J2.5
CAMERA0DP1: J1.10 (6), J2.7
CAMERA0SCL: J1.3 (13), J2.2
CAMERA0SDA: J1.2 (14), J2.1
CAMERA1CN: J5.8, J6.4
CAMERA1CP: J5.7 (9), J6.3
CAMERA1DN0: J5.14 (2), J6.6
CAMERA1DN1: J5.11 (5), J6.8
CAMERA1DP0: J5.13 (3), J6.5
CAMERA1DP1: J5.10 (6), J6.7
CAMERA1SCL: J5.3 (13), J6.2
CAMERA1SDA: J5.2 (14), J6.1
CAMERAGPIO: J1.5 (11), J4.2, J5.5 (11)
GND: C1.2, C2.2, D1.1 (K), J1.6 (10), J1.9 (7), J1.12 (4), J1.15 (1), J2.SHIELD1 (SHIELD), J2.SHIELD2 (SHIELD), J3.2, J4.3, J5.6 (10), J5.9 (7), J5.12 (4), J5.15 (1), J6.SHIELD1 (SHIELD), J6.SHIELD2 (SHIELD), U1.1 (GND/ADJ)
unnamed: D1.2 (A), R1.1

Board: 2 copper layers, 30.0 x 50.0 mm, 13 parts (0 on the bottom side), 21 nets.

Other parts of the board:
REF1, REF2: MountingHole_3.2mm_M3_ISO7380

## KiCad design 2D Top Board/2D Top Board.kicad_pcb

Schematic: 2D Top Board.sch, Camera Selection Board

Parts:
C1: 10uf; T491-3.5x2.8
C2: 100uf; T491-3.5x2.8
C3, C4, C5: 10nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2, J3: Conn_02x15_Top_Bottom; 117342485
J4, J5: Conn_01x02; JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical
J6: 647676-2; TE_647676-2
J7: Conn_01x06; TerminalBlock_bornier-6_P5.08mm
J8, J10: Conn_01x04; JST_PH_B4B-PH-SM4-TB_1x04-1MP_P2.00mm_Vertical
J9: Conn_01x05; JST_PH_B5B-PH-SM4-TB_1x05-1MP_P2.00mm_Vertical
MK1, MK2, MK3, MK4: M2.5; MountingHole_2.7mm_M2.5
P1: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
Q1: BS170; SOT-23-3; MPN BS170; Digi-Key_PN BS170-ND
R3, R4, R5, R6: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RN1: 10K; R_Array_Convex_4x1206
U1: FSA642; QFN50P400X400X60-25N; MPN FSA642
U2: NCP1117-3.3_SOT223; SOT-223-3_TabPin2
U3: LTC4312IMSPBF; MSOP-16_3x4mm_P0.5mm

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, J1.15, J2.15, J3.15, J10.1, R3.1, R4.1, R5.2, R6.1, RN1.5 (R4.2), RN1.6 (R3.2), RN1.7 (R2.2), RN1.8 (R1.2), U1.10 (VCC), U2.2 (VO), U3.1 (DISCEN), U3.2 (VCC), U3.12 (VCC2), U3.16 (*ACC)
+5V: C1.1, J7.3, P1.2, P1.4, U2.3 (VI)
+12V: J6.2, J7.1, J7.2, J8.1, J9.1
CAMERA0CN: J2.8, J2.23, U1.16 (CLKAN)
CAMERA0CP: J2.9, J2.24, U1.17 (CLKAP)
CAMERA0DN0: J2.2, U1.14 (DA1N)
CAMERA0DN1: J2.5, U1.12 (DA2N)
CAMERA0DP0: J2.3, U1.15 (DA1P)
CAMERA0DP1: J2.6, U1.13 (DA2P)
CAMERA0SCL: J2.13, R4.2, U3.3 (SCLOUT1)
CAMERA0SDA: J2.14, R5.1, U3.4 (SDAOUT1)
CAMERA1CN: J3.8, J3.23, U1.23 (CLKBN)
CAMERA1CP: J3.9, J3.24, U1.22 (CLKBP)
CAMERA1DN0: J3.2, U1.21 (DB1N)
CAMERA1DN1: J3.5, U1.18 (DB2N)
CAMERA1DP0: J3.3, U1.20 (DB1P)
CAMERA1DP1: J3.6, U1.19 (DB2P)
CAMERA1SCL: J3.13, RN1.2 (R2.1), U3.7 (SCLOUT2)
CAMERA1SDA: J3.14, RN1.1 (R1.1), U3.8 (SDAOUT2)
CAMERACN: J1.8, J1.23, U1.2 (CLKN)
CAMERACP: J1.9, J1.24, U1.1 (CLKP)
CAMERADN0: J1.2, U1.4 (D1N)
CAMERADN1: J1.5, U1.6 (D2N)
CAMERADP0: J1.3, U1.3 (D1P)
CAMERADP1: J1.6, U1.5 (D2P)
CAMERAGPIO: J1.11, J2.11, J3.11
CAMERASCL: J1.13, RN1.3 (R3.1), U3.6 (SCLIN)
CAMERASDA: J1.14, RN1.4 (R4.1), U3.5 (SDAIN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J1.1, J1.4, J1.7, J1.10, J2.1, J2.4, J2.7, J2.10, J3.1, J3.4, J3.7, J3.10, J4.2, J5.2, J6.1, J7.4, J7.5, J7.6, J8.2, J9.2, J10.4, P1.6, P1.9, P1.14, P1.20, P1.25, P1.30, P1.34, P1.39, Q1.3 (S), U1.8 (/OE), U1.9 (GND), U2.1 (GND), U3.15 (GND)
LASER1: J8.3, P1.11
LASER2: J8.4, P1.13
NOTSEL: Q1.1 (D), R3.2, U3.9 (ENABLE2)
REED: J4.1, P1.35
SEL: P1.15, Q1.2 (G), U1.11 (SEL), U3.10 (ENABLE1)
SWITCH: J5.1, P1.37
SWITCHFAULT: P1.23, R6.2, U3.11 (*FAULT)
Uart3RX: J9.4
Uart3TX: J9.3, P1.7, P1.29
Uart5RX: J10.3, P1.33
Uart5TX: J10.2, P1.32
UartRESET: J9.5, P1.19

Notes on the sheet:
Mounting Holes
Pi Header (Extra Long pins)
Lasers
Stepper Control 1
Camera Out
Camera 0 in
Camera 1 in
Reed Switch
Power Switch
Additional UART control (GPS)
12v power connector
Temporary power connector (for use with external regulator)

Board: 2 copper layers, 84.9 x 59.4 mm, 29 parts (1 on the bottom side), 40 nets.

## Commit log

2020-02-20 First commit.
2020-02-20 Very initial WIP on the simulator.
2020-02-20 Mor WIP - messing about with vectors...
2020-02-20 Now with rubbish removed...
2020-02-23 Simulator geometry working (e. & o. e.).
2020-02-24 Light slicing implemented.
2020-03-01 Create Line Generator PCB
2020-03-02 Removed line generator from Simulator folder; left it in root.
2020-03-02 Tidying line generator circuit diagram.
2020-03-04 WIP on removing shadowed lines from the light-plane/room cross section. Made easy as the calculation is a 2D one in the light plane.
2020-03-06 PCB Layout altered for Adrian's Circuit design
2020-03-07 Changed footprints on Resistors
2020-03-10 Add 2D top board
2020-03-11 Track widths increased
2020-03-11 Updated top board
2020-03-16 More simulator WIP...
2020-03-17 More sim WIP
2020-03-18 Sim WIP
2020-04-03 Add in camera adapter board
2020-04-04 Change to different ZIF connector
2020-04-05 Updated for bigger vias (2mm)
    2.5mm wouldn't quite fit...
2020-04-05 Updated KiCad files
2020-06-01 Setting up to compute visibility polygons in the simulator
2020-06-01 Entire avo spent arsing about with what FreeCAD imagines a polygon to be. Now we have a list of edges for a light slice cutting through the scene.
    Next step - compute their visibility polygon.
2020-06-02 Scanner sim WIP.
2020-06-03 Visibility polygon: logic right (I think...); geometry wrong. WIP
2020-06-04 Visibility polygons now working. (Stupid errors by AB in line intersection code fixed...)
2020-06-04 Removing light lines in space just leaving those in faces. Some bugs remain...
2020-06-05 Visibility polygon calculation now deals with reentrant shapes (I hope...)
2020-06-08 Light sheet simulation now fully working. Some tidying to do.
2020-06-08 Final (?) version of the light sheet code.
2020-06-10 Tidying
2020-06-11 Coding light sheet angle. WIP.
2020-06-11 More light sheet WIP...
2020-06-12 More light sheet WIP.
2020-06-15 Final (?) software for light sheet simulation done.
2020-06-16 More light sheet testing, plus minor correction to algorithm.
2020-06-17 Cameras WIP. Ray-trace from pixel - lines' closest points function implemented.
2020-06-17 First full scanner simulation working. Doubtless bugs remain...
2020-06-17 Added a FIXME tag to the bit I meant to fix...
2020-06-18 Speeding up ray tracing by precomputing a mask of pixels to be traced. WIP.
2020-06-19 Tidying and removing a few bugs from the simulator.
2020-06-25 Separated out functions to make an image of the room under 'natural' light, and to make an image of the light sheet hitting the surfaces.
2020-06-26 Updating PCBs
2020-07-11 Work In progress 2D Scanner STEP file
    White parts - 3D Printed (these should be relatively obvious!)
    Silver parts - Aluminium
    Black parts - Hard anodized Aluminium
    Blue Parts - Laser cut acrylic
    This is a WIP assembly, I haven't added anything (yet) to stop the laser and cameras rotating about their respective axis yet, nor anything to adjust the friction on the rotary axis (the spring and w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
2020-07-13 Changed the simulator file name to end .py as it is a Python program.
    Moved all the graphics calls into a simple interface to allow different graphics libraries to be used.
2020-07-16 Work in progress 2D Scanner STEP
    More progress. Not yet added an on off switch or reed switch
2020-07-17 Now includes the HQ cam.
    Current settings are:
    Camera type 1
    Camera 1 offset 345mm
    Camera 2 offset 450mm
    Cam 1 max resolution 2mm
    cam 2 max resolution 4mm
2020-07-20 STEP file moved to G Drive
2020-07-27 Adding camera calculation spreadsheets.
2020-07-28 Added calculation for L to the camera spreadsheet.
2020-08-27 Create TopBoardTester.ino
    Top board testing program for Arduino - doesn't work!
2020-09-01 Update TopBoardTester.ino
    Updated top board tester
2020-09-01 Update TopBoardTester.ino
    Mistakes corrected. Now works perfectly!
2020-09-08 Library files added
2020-09-08 updated library paths
2020-09-08 i2c only version added
2020-09-11 Corrected MC14555BDG to include a GND connection
2020-09-21 Added new temprary top board; small redesign by AB to make easier to cut.
2020-09-21 GCodes for cutting new PCB done.
2020-09-29 STL Files for Lens bodies added
2020-10-03 STL files for printing
2020-10-04 New mounts for vertical screen and rotated pi
2020-10-09 Find point in space from camera pixel added to simulator.
2020-10-10 New Lens mounts, new Pi mount (adjustable)
2020-10-10 Added base parts
2020-10-10 Create SS2DP081 Additional Back Panel Mount.stl
    Added panel mount
2020-11-02 Separating simulator model from FreeCAD dependency. W.I.P.
2020-11-04 Separating out scanner simulation from FreeCAD. W.I.P.
2020-11-11 Simulator now has the scanner model separated from all FreeCAD calls. It still has bugs, but it all runs with no class or syntax errors.
2020-11-12 More simulator WIP
2020-11-12 Debugging matrix class
2020-11-12 More progress, but still not right...
2020-11-12 This time with picture
2020-11-13 Further work on the simulator. Now more wrong. But tidier...
2020-11-16 Fixing simulator. WIP
2020-11-17 Debugging simulator WIP
2020-11-18 Tiny correction.
2020-11-19 Debugging getting somewhere... WIP
2020-11-19 Now very nearly working. Still one glitch to remove.
2021-01-14 Improved (?) constant current circuits for the line generator V2.
2021-01-14 Now with 5V power...
2021-01-14 Now with adjustable LED current.
2021-01-22 Latest laser circuit. Maybe final?!?
2021-01-26 PCB layout
2021-01-27 Updated PCB layout
    Added vias to improve soldering
2021-01-27 Minor changes
2021-01-28 Updated PCB layout as per AB suggestion
2021-02-08 WIP on the calibration simulation.
2021-02-12 New Camera Adapter
    For USB C, with 3.3v voltage protection circuit
2021-03-01 Fixing small bugs in the simulator...
2021-03-02 Beginning to develop the calibration software. WIP...
2021-03-03 WIP on scanner calibration.
2021-03-05 Calibration proposal document added.
2021-03-05 Final Line Generator for prototype production
2021-03-05 Update to camera adapter
2021-03-16 Set up the calibration simulation as a PyCharm IDE project.
2021-03-16 Calibration program WIP.
2021-03-17 Code tidying.
    Calibration WIP.
    There's an error somewhere (or maybe it's the ill-conditioned
    nature of the problem, in which case, Arrrgh!) because feeding triangle corners into a scanner
    with zero errors gives a sum of squared errors that is not zero.
    More WIP needed. Also needed: gradient descent function minimisation; there may well be
    a Python library somewhere for this. To be done.
2021-03-22 Calibration WIP.
2021-03-26 Bug hunting...
2021-03-26 More bug hunting
2021-03-26 Fixed projection bug. Now to tidy the code and so reintroduce them...
2021-03-26 Added random exploration of the space of scanner parameters.
2021-03-26 Code tidying. Note - optimisation is against triangle side lengths, not triangle position (which will be unknown in real life). It turns out you can get a better optimum with a bent scanner, which gi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
    Needs more thought...
2021-04-06 Fixed bug in scanner simulation function that intersects rays and planes. Now reconstructs points in space accurately. Calibration using random configurations of scanner works, but is not accurate en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
2021-04-07 Code tidying.
2021-04-07 This time with added spelling...
2021-04-07 Scanner calibration now uses scipy's minimize() multidimensional optimisation to get a scanner that reconstructs the test triangles as close as possible. It does this well (RMS error of all triangle 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
    Conjecture - we need to do the calibration at more than one Z value to pin
    things down. To be investigated...
2021-04-08 Final (?) version of the calibration program.
    Results of the calibration experiments indicate that calibrating just using
    triangle side lengths gives a poor result, whereas calibrating against known
    points in space gives superb results.
    Maybe a big frame with white-painted vertical wires in known positions
    against a black background?
2021-04-28 Simulation of using a piece of A4 paper to check for scanner errors in the field added.
2021-04-28 Trying the A4 paper idea with smaller errors.
2021-08-08 Small bit of code tidying.
2021-09-27 WIP calibration...
2021-09-28 More WIP...
2021-09-29 Scanner definition simplified.
2021-10-01 Tidying optimisation vector.
2021-10-01 YowieScanner.py has moved to scannerV4
2021-10-03 Optimising the scanner parameters against a real world scan.
2021-10-05 More messing about with calibration...
2021-10-06 Added test card.
2021-10-06 WIP - adding a selection vector for the optimiser...
2021-10-07 WIP - tidying the optimisation code.
2021-10-08 Some bugs removed...
2021-10-11 Getting the FreeCAD simulator up to date with other changes.
2021-10-12 Getting somewhere with the optimiser...
2021-10-12 More optimisation experiments.
2021-10-12 Added whole scanner rotation to the optimisation.
2021-10-13 A working version, I think...
2021-10-14 Experiments with the scanner...
2021-10-15 Working version!
2021-10-18 Added code to deal with optimisation from scanning triangles.
2021-10-19 Playing about with the triangle optimisation. Why don't we get zero error out for zero in?
2021-10-27 Experimenting with the optimisaer creating scanner confrigurations WIP
2021-10-29 Bug in triangle calibration simulation fixed.
2021-11-04 Calibration WIP...
2021-11-09 Triangle calibration WIP...
2021-11-09 Interactive calibration: some progress... Not yet finished.
2021-11-15 More work on the calibration from scanned triangles...
2021-11-18 Calibration WIP. Triangle fitting by optimisation still not working...
2021-11-23 Fixed parametric line distance bug and triangle sum of squares bug. Works better now...
2021-11-30 Triangle point sampling added to speed up triangle fitting.
2021-12-06 Code tidying and commenting.
2022-04-05 Making sure repo is up to date.
