# Repository Yowie-Tool/Scanner-Dev

## KiCad design Small Camera Adapter/Small Camera Adapter.kicad_pcb

Parts:
C1: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 47nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: D_Zener 3.3V; D_SOD-123F
D3: Q_SCR_KAG; DPAK
J1: 68611514122
J2: 10137062-00021LF; CONN_10137062-00021LF; PARTREV B
R1: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 1K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Connections:
3.3VProtected: C1.1, D2.1 (K), D3.2 (A), J1.1 (15), J2.A4 (VBUS_A), J2.A9 (VBUS_A), J2.B4 (VBUS_B), J2.B9 (VBUS_B), R2.1
CAMERACN: J1.8, J2.A8 (SBU1), J2.B8 (SBU2)
CAMERACP: J1.7 (9), J2.A5 (CC1), J2.B5 (CC2)
CAMERADN0: J1.14 (2), J2.A3 (SSTXN1), J2.B3 (SSTXN2)
CAMERADN1: J1.11 (5), J2.A7 (DN1), J2.B7 (DN2)
CAMERADP0: J1.13 (3), J2.A2 (SSTXP1), J2.B2 (SSTXP2)
CAMERADP1: J1.10 (6), J2.A6 (DP1), J2.B6 (DP2)
CAMERAGPIO: J1.5 (11)
CAMERASCL: J1.3 (13), J2.A11 (SSRXP2), J2.B11 (SSRXP1)
CAMERASDA: J1.2 (14), J2.A10 (SSRXN2), J2.B10 (SSRXN1)
GND: C1.2, C2.2, D1.1 (K), D3.1 (K), J1.6 (10), J1.9 (7), J1.12 (4), J1.15 (1), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J2.S2 (SHIELD), J2.S3 (SHIELD), J2.S4 (SHIELD), R1.1
unnamed: C2.1, D2.2 (A), D3.3 (G), R1.2
unnamed: D1.2 (A), R2.2

Board: 2 copper layers, 24.9 x 25.0 mm, 13 parts (5 on the bottom side), 12 nets.

Other parts of the board:
REF1, REF2, REF3, REF4: MountingHole_2.2mm_M2

## KiCad design Line Generator/Line-generator-V2/Line-Generator-V2.kicad_pcb

Board: 2 copper layers, 41.0 x 29.2 mm, 24 parts (1 on the bottom side), 20 nets.

Parts:
C1, C2, C3: 100nF; C_0805_2012Metric
D1, D3: MMSZ4679T1G 2V; D_SOD-123
D2: LED_Dual_ACA; PinSocket_1x03_P1.27mm_Vertical
H1, H4: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
Q1, Q4: BS170F; SOT-23
Q2, Q3: BCP5310; SOT-223-3_TabPin2
R1, R8: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R6: 100K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R7: 47K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4: 5R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 10R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1, RV2: 100K; Potentiometer_Bourns_3386C_Horizontal
U1: TLC272; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C1.1, C2.1, C3.1, D1.1, D3.1, J1.1, R4.2, R5.2, RV1.1, RV2.3, U1.8
GND: C1.2, D2.2, H1.1, H4.1, J1.2, Q1.2, Q4.2, U1.4
Laser1: J1.3, R1.2
Laser2: J1.4, R8.2
unnamed: C2.2, RV1.2, U1.3
unnamed: C3.2, RV2.2, U1.5
unnamed: D1.2, R2.2, R3.1
unnamed: D2.1, Q2.2
unnamed: D2.3, Q3.2
unnamed: D3.2, R6.2, R7.1
unnamed: Q1.1, R1.1
unnamed: Q1.3, R3.2
unnamed: Q2.1, U1.1
unnamed: Q2.3, R4.1, U1.2
unnamed: Q3.1, U1.7
unnamed: Q3.3, R5.1, U1.6
unnamed: Q4.1, R8.1
unnamed: Q4.3, R7.2
unnamed: R2.1, RV1.3
unnamed: R6.1, RV2.1

## KiCad design TempTopBoard/Temp Top Board.kicad_pcb

Schematic: Temp Top Board.sch, Camera Selection Board

Parts:
C1, C2: 100uF; CP_Radial_D8.0mm_P3.50mm
J1, J3: Conn_01x02; PinHeader_1x02_P2.54mm_Horizontal
J2, J6: Conn_01x05; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical
J4: Conn_01x04; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J5: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J7: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J8: Conn_01x03; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J11, J12: Conn_01x02; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
MK1, MK2, MK3, MK4: M2.5; MountingHole_2.7mm_M2.5
P1: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
R1: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R14, R15: 1K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: IRFML8244TRPBF; SOT95P240X112-3N
U2: LM7805_TO220; TO-220-3_Vertical

Connections:
+3V3: J2.1, P1.1, P1.17, R14.2, R15.2
+5V: C2.1, J1.1, J3.1, J7.1, U2.3 (VO)
+12V: C1.1, J4.1, J5.1, J6.1, J8.1, U2.1 (VI)
CAMERAGPIO: J8.2
GND: C1.2, C2.2, J1.2, J2.5, J3.2, J4.2, J5.2, J6.5, J8.3, P1.6, P1.9, P1.14, P1.20, P1.25, P1.30, P1.34, P1.39, U1.2 (S), U2.2 (GND)
LASER1: J4.3, P1.29
LASER2: J4.4, P1.31
LASER3: P1.33, R1.2
unnamed: J7.2, U1.3 (D)
unnamed: J11.2, R14.1
unnamed: J12.2, R15.1
unnamed: R1.1, U1.1 (G)
OE1: J2.3, P1.16
OE2: J2.4, P1.12
REED: J11.1, P1.35
SEL: J2.2, P1.18
SWITCH: J12.1, P1.37
Uart0RX: J6.3, P1.10
Uart0TX: J6.2, P1.8
UartRESET: J6.4

Notes on the sheet:
Mounting Holes
Pi Header (Extra Long pins)
Laser 1/2
Stepper Control 1
Reed Switch
Power Switch
Camera 0/1 Power
12V power
External Camera Switcher

Board: 2 copper layers, 64.9 x 61.9 mm, 22 parts (5 on the bottom side), 18 nets.

## KiCad design New Top Board/Top Board.kicad_pcb

Schematic: Top Board.sch, Camera Selection Board

Parts:
C1, C2, C3, C4, C5: 10nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J4, J10: Conn_01x04; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J2: 68611514122
J3: Conn_01x06; JST_PH_B6B-PH-K_1x06_P2.00mm_Vertical
J5: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J6, J7: Conn_01x05; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical
J8, J9: Conn_01x03; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J11, J12: Conn_01x02; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J13, J14: RJE392881400; Mouser Part Number 523-RJE392881400
MK1, MK2, MK3, MK4: M2.5; MountingHole_2.7mm_M2.5
P1: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
R11, R12, R13: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R14, R15: 1K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
RN1, RN2: 10K; R_Array_Convex_4x1206
U2: LTC4314; SOP65P777X199-20N; MPN LTC4314
U3, U7: FSA642; FSA642UMX; MPN FSA642
U5: MC14555BCPG; SOIC127P600X175-16N

Connections:
5VPROTECTED: P1.2, P1.4
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, J3.1, J3.5, J10.1, P1.1, P1.17, R11.2, R12.1, R13.1, R14.2, R15.2, RN1.1 (R1.1), RN1.2 (R2.1), RN1.3 (R3.1), RN1.4 (R4.1), RN2.5 (R4.2), RN2.6 (R3.2), RN2.7 (R2.2), RN2.8 (R1.2), U2.1 (DISCEN), U2.2 (VCC), U2.16 (VCC2), U2.20 (~ACC), U3.10 (VCC), U5.16 (VDD), U7.10 (VCC)
+12V: J1.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1
CAMERA0CN: J13.5, U3.16 (CLKAN)
CAMERA0CP: J13.6, U3.17 (CLKAP)
CAMERA0DN0: J13.3, U3.14 (DA1N)
CAMERA0DN1: J13.1, U3.12 (DA2N)
CAMERA0DP0: J13.4, U3.15 (DA1P)
CAMERA0DP1: J13.2, U3.13 (DA2P)
CAMERA0SCL: J13.7, R13.2, U2.3 (SCLOUT1)
CAMERA0SDA: J13.8, R12.2, U2.4 (SDAOUT1)
CAMERA1CN: J13.13, U3.23 (CLKBN)
CAMERA1CP: J13.14, U3.22 (CLKBP)
CAMERA1DN0: J13.11, U3.21 (DB1N)
CAMERA1DN1: J13.9, U3.18 (DB2N)
CAMERA1DP0: J13.12, U3.20 (DB1P)
CAMERA1DP1: J13.10, U3.19 (DB2P)
CAMERA1SCL: J13.15, RN2.3 (R3.1), U2.7 (SCLOUT2)
CAMERA1SDA: J13.16, RN2.4 (R4.1), U2.8 (SDAOUT2)
CAMERA2CN: J14.5, U7.16 (CLKAN)
CAMERA2CP: J14.6, U7.17 (CLKAP)
CAMERA2DN0: J14.3, U7.14 (DA1N)
CAMERA2DN1: J14.1, U7.12 (DA2N)
CAMERA2DP0: J14.4, U7.15 (DA1P)
CAMERA2DP1: J14.2, U7.13 (DA2P)
CAMERA2SCL: J14.7, R11.1, U2.13 (SCLOUT3)
CAMERA2SDA: J14.8, RN1.5 (R4.2), U2.14 (SDAOUT3)
CAMERA3CN: J14.13, U7.23 (CLKBN)
CAMERA3CP: J14.14, U7.22 (CLKBP)
CAMERA3DN0: J14.11, U7.21 (DB1N)
CAMERA3DN1: J14.9, U7.18 (DB2N)
CAMERA3DP0: J14.12, U7.20 (DB1P)
CAMERA3DP1: J14.10, U7.19 (DB2P)
CAMERA3SCL: J14.15, RN1.7 (R2.2), U2.17 (SCLOUT4)
CAMERA3SDA: J14.16, RN1.8 (R1.2), U2.18 (SDAOUT4)
CAMERACN: J2.8, U3.2 (CLKN), U7.2 (CLKN)
CAMERACP: J2.7 (9), U3.1 (CLKP), U7.1 (CLKP)
CAMERADN0: J2.14 (2), U3.4 (D1N), U7.4 (D1N)
CAMERADN1: J2.11 (5), U3.6 (D2N), U7.6 (D2N)
CAMERADP0: J2.13 (3), U3.3 (D1P), U7.3 (D1P)
CAMERADP1: J2.10 (6), U3.5 (D2P), U7.5 (D2P)
CAMERAGPIO: J2.5 (11), J8.2, J9.2
CAMERASCL: J2.3 (13), RN2.2 (R2.1), U2.6 (SCLIN)
CAMERASDA: J2.2 (14), RN2.1 (R1.1), U2.5 (SDAIN)
ENABLE1: U2.12 (ENABLE1), U5.4 (Q0A)
ENABLE2: U2.11 (ENABLE2), U5.5 (Q1A)
ENABLE3: U2.10 (ENABLE3), U5.6 (Q2A)
ENABLE4: U2.9 (ENABLE4), U5.7 (Q3A)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J1.2, J2.6 (10), J2.9 (7), J2.12 (4), J2.15 (1), J3.2, J4.2, J5.2, J6.5, J7.5, J8.3, J9.3, J10.4, J13.MH1, J13.MH2, J14.MH1, J14.MH2, P1.6, P1.9, P1.14, P1.20, P1.25, P1.30, P1.34, P1.39, U2.19 (GND), U3.9 (GND), U5.1 (~EA~), U5.8 (VSS), U5.13 (BB), U5.14 (AB), U7.9 (GND)
INTERRUPT: J3.6, P1.22
LASER1: J4.3, P1.15
LASER2: J4.4, P1.16
LASER3: J1.3, P1.26
LASER4: J1.4, P1.36
unnamed: J11.2, R14.1
unnamed: J12.2, R15.1
OE1: P1.11, U3.8 (/OE), U5.3 (BA), U5.15 (~EB~)
OE1I: U5.12 (Q0B), U7.8 (/OE)
REED: J11.1, P1.35
SCL: J3.3, P1.5
SDA: J3.4, P1.3
SEL: P1.12, U3.11 (SEL), U5.2 (AA), U7.11 (SEL)
SWITCH: J12.1, P1.37
SWITCHFAULT: P1.38, RN1.6 (R3.2), U2.15 (~FAULT)
Spi0CE0: P1.24
Spi0MISO: P1.21
Spi0MOSI: P1.19
Spi0SCLK: P1.23
Uart0RX: J6.3, P1.10
Uart0TX: J6.2, P1.8
Uart3RX: J10.3
Uart3TX: J10.2, P1.7, P1.29
Uart5RX: J7.3, P1.33
Uart5TX: J7.2, P1.32
UartRESET: J6.4, J7.4, P1.18

Notes on the sheet:
Mounting Holes
Pi Header (Extra Long pins)
Laser 1/2
Laser 3/4
Logic circuit
Stepper Control 2
Stepper Control 1
Camera Out
Camera 0/1 in
Camera 2/3 in
Reed Switch
Power Switch
Additional UART control (GPS)
Camera 0/1 Power
Camera 2/3 Power
MPU6050 External
12V power

Board: 2 copper layers, 84.9 x 67.9 mm, 35 parts (18 on the bottom side), 70 nets.

File New Top Board/Top Board_bom_1.csv:

Component,Description,Part,References,Value,Footprint,Quantity Per PCB,Datasheet,Field4,Field5,Field6,Field7,Field8,Height,Manufacturer_Name,Manufacturer_Part_Number,Mouser Part Number,Mouser Price/Stock,Category,Family,MPN,Manufacturer,Status
1,Capacitor symbol for simulation only,CAP,C1 C2 C3 C4 C5,10nF,C_0603_1608Metric_Pad1.05x0.95mm_HandSolder,5,~,,,,,,,,,,,,,,,
2,,68611514122,J2,68611514122,68611514122,1,None,68611514122,None,Unavailable,Connector [Würth Elektronik] 68611514122 Connector,Würth Elektronik,,,,,,,,,,
3,"Generic connector, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x02,J11 J12,Conn_01x02,JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,2,~,,,,,,,,,,,,,,,
4,"Generic connector, single row, 01x03, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x03,J8 J9,Conn_01x03,JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical,2,~,,,,,,,,,,,,,,,
5,"Generic connector, single row, 01x04, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x04,J1 J4 J10,Conn_01x04,JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical,3,~,,,,,,,,,,,,,,,
6,"Generic connector, single row, 01x05, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x05,J6 J7,Conn_01x05,JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical,2,~,,,,,,,,,,,,,,,
7,"Generic connector, single row, 01x06, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x06,J3,Conn_01x06,JST_PH_B6B-PH-K_1x06_P2.00mm_Vertical,1,~,,,,,,,,,,,,,,,
8,"Modular Connectors / Ethernet Connectors RA Two Port With Shield, no LED",RJE392881400,J13 J14,RJE392881400,RJE392881400,2,https://componentsearchengine.com/Datasheets/1/RJE392881400.pdf,,,,,,13.2,Amphenol,RJE392881400,523-RJE392881400,https://www.mouser.com/Search/Refine.aspx?Keyword=523-RJE392881400,,,,,
9,"Generic screw terminal, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/)",Screw_Terminal_01x02,J5,Screw_Terminal_01x02,TerminalBlock_bornier-2_P5.08mm,1,~,,,,,,,,,,,,,,,
10,"Generic connector, double row, 02x20, odd/even pin numbering scheme (row 1 odd numbers, row 2 even numbers), script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_02x20_Odd_Even,P1,Conn_02x20_Odd_Even,PinSocket_2x20_P2.54mm_Vertical,1,,,,,,,,,,,,,,,,
11,Resistor,R,R11 R12 R13,10K,R_0805_2012Metric_Pad1.15x1.40mm_HandSolder,3,~,,,,,,,,,,,,,,,
12,Resistor,R,R14 R15,1K,R_0603_1608Metric_Pad1.05x0.95mm_HandSolder,2,~,,,,,,,,,,,,,,,
13,"4 resistor network, parallel topology, DIP package",R_Pack04,RN1 RN2,10K,R_Array_Convex_4x1206,2,~,,,,,,,,,,,,,,,
14,IC I2C SW 8CH W/RESET 24TSSOP,FSA642,U3 U7,FSA642,QFN50P400X400X60-25N,2,http://www.ti.com/general/docs/suppproductinfo.tsp?distId=10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,,,,,,,,,,,Integrated Circuits (ICs),"Logic - Signal Switches, Multiplexers, Decoders",FSA642,Fairchild,Active
15,IC I2C SW 8CH W/RESET 24TSSOP,LTC4314,U2,LTC4314,SOP65P777X199-20N,1,http://www.ti.com/general/docs/suppproductinfo.tsp?distId=10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,,,,,,,,,,,Integrated Circuits (ICs),"Logic - Signal Switches, Multiplexers, Decoders",LTC4314,Linear Technology,Active
16,,MC14555BCPG,U5,MC14555BCPG,SOIC127P600X175-16N,1,,,,,,,,,,,,,,,,

Component Groups:,16
Component Count:,31
Fitted Components:,31
Number of PCBs:,1
Total components:,31
Schematic Version:,1
Schematic Date:,2020-01-29
PCB Variant:,default
BoM Date:,08/05/2020 20:28:33
Schematic Source:,Top Board.sch
KiCad Version:,Eeschema (5.1.0)-1

## KiCad design Universal Interface Board/Universal Interface Board - Copy.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_3001_1x12mm
Cin1: 100uF; CP_Radial_D6.3mm_P2.50mm
Cin2, Cin3, Cin6: 10uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
Cin4: 680uF; CP_Radial_D10.0mm_P5.00mm
Cin5: 10nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Cin7, Cin8: 100nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Cin9: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Cout1, Cout3: 22uF; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
Cout2: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Cout4: 2.2nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1: BAS21H; D_SOD-123F
F1: Fuse 1A; Fuse_Littelfuse_395Series
J1, J2: 647676-2; TE_647676-2
J3: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J5: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J6: Conn_01x02; PinHeader_1x02_P2.54mm_Horizontal
L1: 22uH; L_Wuerth_HCI-7050
M1: Fan; SolderWirePad_1x02_P3.81mm_Drill1mm
MK1, MK2, MK3, MK4: M2.5; MountingHole_2.7mm_M2.5
P1: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
Q1, Q2: BSS138; SOT-23-3; MPN BSS138; Digi-Key_PN BSS138CT-ND
Q3: DMG2305UX-7; SOT91P240X110-3N_DMG2305UX-7
Q4: DMMT5401-7; SOT26
Q5: IRFML8244TRPBF; SOT-23
R1: 10K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R2, R3, R7, R8: 4.7K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R4: 1K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R5: 47K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R6: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RN1: 10K; R_Array_Convex_4x1206
U1: CAT24C128; SOIC-8_3.9x4.9mm_P1.27mm
U2: LF50_TO220; DPAK
U3: DS1307_; SOIC-8_3.9x4.9mm_P1.27mm; MPN DS1307+; Digi-Key_PN DS1307+-ND
U4: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U6: 193-4043
Y1: Crystal_GND23; Crystal_SMD_Abracon_ABS25-4Pin_8.0x3.8mm

Connections:
5VPROTECTED: P1.2, P1.4, Q3.2 (S), Q4.5 (E2)
+3V3: Cin5.1, Cin7.2, Cin9.2, P1.1, P1.17, R2.2, R3.2, R4.2, R7.2, R8.2, RN1.7 (R2.2), RN1.8 (R1.2), U1.8 (VCC), U4.8 (VDDIO), U4.9 (AD0), U4.13 (VDD)
+5V: Cin8.1, Cout1.1, Q3.3 (D), Q4.6 (E1), RN1.5 (R4.2), RN1.6 (R3.2), U3.8 (VCC), U6.3 (VO)
+12V: Cin6.1, D1.1 (K), F1.2, J1.2, J2.2, J3.1, M1.1 (+), U2.1 (VI)
FAN: P1.13, R1.2
GND: BT1.2 (-), Cin1.2, Cin2.2, Cin3.2, Cin4.2, Cin5.2, Cin6.2, Cin7.1, Cin8.2, Cin9.1, Cout1.2, Cout2.1, Cout3.2, Cout4.1, J1.1, J2.1, J3.2, J5.2, J6.2, P1.6, P1.9, P1.14, P1.20, P1.25, P1.30, P1.34, P1.39, Q5.2 (S), R5.2, R6.1, U1.1 (A0), U1.2 (A1), U1.3 (A2), U1.4 (GND), U2.2 (GND), U3.4 (GND), U4.11 (FSYNC), U4.18 (GND), U6.2 (GND), Y1.2, Y1.3
ID_SC: P1.28, R3.1, U1.6 (SCL)
ID_SD: P1.27, R2.1, U1.5 (SDA)
INTERRUPT: P1.22, U4.12 (INT)
unnamed: BT1.1 (+), U3.3 (VBAT)
unnamed: Cin1.1, Cin2.1, F1.1, L1.1
unnamed: Cin3.1, Cin4.1, L1.2, U6.1 (VI)
unnamed: Cout2.2, U4.10 (REGOUT)
unnamed: Cout3.1, J6.1, U2.3 (VO)
unnamed: Cout4.2, U4.20 (CPOUT)
unnamed: D1.2 (A), M1.2 (-), Q5.3 (D)
unnamed: J5.1, R4.1, U1.7 (WP)
unnamed: Q1.3 (D), RN1.4 (R4.1), U3.5 (SDA)
unnamed: Q2.3 (D), RN1.3 (R3.1), U3.6 (SCL)
unnamed: Q3.1 (G), Q4.4 (C2), R5.1
unnamed: Q4.1 (C1), Q4.2 (B1), Q4.3 (B2), R6.2
unnamed: Q5.1 (G), R1.1
unnamed: U3.1 (X1), Y1.1
unnamed: U3.2 (X2), Y1.4
SCL: P1.5, Q2.1 (G), Q2.2 (S), R7.1, RN1.1 (R1.1), U4.23 (SCL)
SDA: P1.3, Q1.1 (G), Q1.2 (S), R8.1, RN1.2 (R2.1), U4.24 (SDA)

Notes on the sheet:
Mounting Holes
Pi Header (Extra Long pins)
Pi Voltage Protection Circuit
5V 2A Pi Voltage Regulation Circuit
Real Time Clock Circuit
Main power connector
Additional Capacitor Connector
12V Fan control circuit
Upper Board Power Connector 1
Screen power connector
EEPROM Circuit
Optional fit Gyroscope Circuit
